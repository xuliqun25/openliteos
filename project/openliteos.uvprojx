# Keil uVision project openliteos.uvprojx, settings and files
target protocols (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: openliteos
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429_439xx,USE_STDPERIPH_DRIVER,
  c include: ..\kernel\include;..\kernel\base\include;..\kernel\base\mem;..\fire\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\fire\Libraries\CMSIS\Include;..\fire\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\user\Bsp;..\platform\bsp;..\platform\cpu;..\user;..\net\lwip-2.0.3\src\include;..\user\conf;..\net\lwip-2.0.3\ports;..\kernel\cmsis;..\user\App
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\user\HuaweiLiteOS_cortexM.sct
  group kernel
    ../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../kernel/base/misc/: los_misc.c
    ../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
  group platform
    ../platform/bsp/: los_config.c
    ../platform/cpu/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch.s los_vendor.s
  group cmsis
    ../fire/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group cmsis_liteos
    ../kernel/cmsis/: cmsis_liteos.c
  group driver
    ../fire/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group bsp
    ../user/Bsp/key/: bsp_key.c
    ../user/Bsp/LAN8742A/: LAN8742A.c stm32f429_eth.c
    ../user/Bsp/led/: bsp_led.c
    ../user/Bsp/systick/: bsp_SysTick.c
    ../user/Bsp/usart/: bsp_debug_usart.c
  group lwip
    ../net/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../net/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../net/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../net/lwip-2.0.3/src/netif/: ethernet.c
  group lwip_port
    ../net/lwip-2.0.3/ports/src/: ethernetif.c sys_arch.c
  group user
    ../user/: main.c stm32f4xx_it.c
    ../user/App/: netconf.c udp_echoclient.c
software components: CMSIS:CORE 4.3.0
